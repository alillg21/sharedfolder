# IAR project KF352App.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: KF352=0x04; DEBUG=1; POS_TYPE=0x04
  ICCARM.CCDiagSuppress: Pe111,Pe550,Pe188
  ICCARM.CCIncludePath2: ../../inc; ../../sdk/KF352/BaseSdk-inc; ../../sdk/KF352/PubSdk-inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KF352App.bin
  ILINK.IlinkOutputFile: KF352App.out
  ILINK.IlinkIcfFile: KF352App.icf
  ILINK.IlinkProgramEntryLabel: common_startup
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: KF352App.icf
  group inc
    ../../inc/: typedef.h
  group sdk/lib
    ../../sdk/KF352/: KF352BaseSDK.a KF352PublicSDK.a libdev.a
  group sdk/sdk-inc/BaseSdk-inc
    ../../sdk/KF352/BaseSdk-inc/: sdkBluetooth.h sdkCamera.h sdkDebug.h sdkEthernet.h sdkFingerprint.h sdkGlobal.h sdkGps.h sdkIcCard.h sdkKBkey.h sdkLCD.h sdkMagCard.h sdkMath.h sdkMngLink.h sdkMngMem.h sdkMngMessage.h sdkMnt.h sdkModem.h sdkPed.h sdkPPP.h sdkPrint.h sdkRfCard.h sdkScanGun.h sdkSystem.h sdkTools.h sdkTypeDef.h sdkUART.h sdkVoice.h sdkWifi.h sdkWnet.h
  group sdk/sdk-inc/PubSdk-inc
    ../../sdk/KF352/PubSdk-inc/: sdkCardOperate.h sdkComm.h sdkDisp.h sdkIni.h sdkInput.h sdkPrintExt.h sdkPubGlobal.h sdkSys.h sdkUI.h
  group src
    ../../src/: main.c
